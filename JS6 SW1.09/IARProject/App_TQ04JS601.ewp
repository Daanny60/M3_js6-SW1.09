# IAR project App_TQ04JS601.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: FM33LG02x FMSH FM33LG02x
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 29
  General.FPU2: 0
  ICCARM.CCDefines: __ICCARM__
  ICCARM.CCIncludePath2: ..\Source\App; ..\Source\ComStack\Can_Gen\Can; ..\Source\ComStack\Can_Gen\CanIf; ..\Source\ComStack\Can_Gen\CanTp; ..\Source\ComStack\Can_Gen\Com; ..\Source\ComStack\Can_Gen\Dcm; ..\Source\ComStack\CanDriver; ..\Source\ComStack\CanInterface\Det; ..\Source\ComStack\CanInterface\Dem; ..\Source\ComStack\CanInterface; ..\Source\ComStack\CanTp; ..\Source\ComStack\CanTrcv; ..\Source\ComStack\Ccp; ..\Source\ComStack\Com; ..\Source\ComStack\Common; ..\Source\ComStack\Dcm; ..\Source\ComStack\DEM; ..\Source\ComStack\OsekNm; ..\Source\ComStack\PDUR; ..\Source\Drivers\CMSIS\Device\FM\FM33xx\Include; ..\Source\Drivers\CMSIS\Device\FM\FM33xx\Include; ..\Source\Drivers\FM33LG0xx_FL_Driver\Inc; ..\Source\drv; ..\Source\MF-config\Inc; ..\Source\types; ..\Source\drv\Adc; ..\Source\drv\DMA; ..\Source\drv\GPIO; ..\Source\drv\Keyboard; ..\Source\drv\PLL; ..\Source\drv\PWM; ..\Source\drv\Sleep; ..\Source\drv\Tim; ..\Source\drv\Encoder; ..\Source\drv\Event; ..\Source\drv\EE_Flash; ..\Source\drv\Memory; ..\Source\ComStack\AutoSarNm; ..\Source\drv\svd; ..\Source\ComStack\Can_Gen\OsekNm
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: App_TQ04JS601_SW1.08_20241123.hex
  ILINK.IlinkOutputFile: App_TQ04JS601.out
  ILINK.IlinkIcfFile: linker\FM33LG02x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Source
    ../Source/: main.c
  group Source/App
    ../Source/App/: App_Boot.c App_Boot.h App_BootCfg.c App_BootCfg.h App_Can.c App_Can.h App_Demm.c App_Demm.h App_Encoder.c App_Encoder.h App_Keyboard.c App_Keyboard.h App_Led.c App_Led.h App_PID.c App_Rgb.c App_Rgb.h App_WheelHeat.c App_WheelHeat.h LowPowerManage.c LowPowerManage.h system_voltage_manage.c system_voltage_manage.h
  group Source/ComStack/Can_Gen/Can
    ../Source/ComStack/Can_Gen/Can/: Can_Cfg.h Can_PBcfg.c
  group Source/ComStack/Can_Gen/CanIf
    ../Source/ComStack/Can_Gen/CanIf/: CanIf_Cfg.h CanIf_Lcfg.c
  group Source/ComStack/Can_Gen/CanTp
    ../Source/ComStack/Can_Gen/CanTp/: CanTp_Cfg.h CanTp_PBcfg.c
  group Source/ComStack/Can_Gen/Com
    ../Source/ComStack/Can_Gen/Com/: App_Com.c Com_Cfg.c Com_Cfg.h Com_Lcfg.c
  group Source/ComStack/Can_Gen/Dcm
    ../Source/ComStack/Can_Gen/Dcm/: App_Dcm.c Dcm_Cfg.c Dcm_Cfg.h Dcm_Lcfg.c
  group Source/ComStack/Can_Gen/OsekNm
    ../Source/ComStack/Can_Gen/OsekNm/: OsekNm.c OsekNm.h OsekNm_App.c OsekNm_Cfg.c OsekNm_Cfg.h
  group Source/ComStack/CanDriver
    ../Source/ComStack/CanDriver/: Can.c Can.h Can_Cbk.c Can_Pl.h Can_Type.h
  group Source/ComStack/CanInterface
    ../Source/ComStack/CanInterface/: CanIf.c CanIf.h CanIf_Cbk.h CanIf_Type.h
  group Source/ComStack/CanInterface/Dem
    ../Source/ComStack/CanInterface/Dem/: Dem.c Dem.h Dem_Cfg.c DEM_Cfg.h Dem_IntErrId.h DEM_types.h Demm.c Demm.h
  group Source/ComStack/CanInterface/Det
    ../Source/ComStack/CanInterface/Det/: Det.c Det.h
  group Source/ComStack/CanTp
    ../Source/ComStack/CanTp/: CanTp.c CanTp.h CanTp_Cbk.h
  group Source/ComStack/CanTrcv
    ../Source/ComStack/CanTrcv/: CanTrcv.c CanTrcv.h
  group Source/ComStack/Ccp
    ../Source/ComStack/Ccp/: App_Ccp.c Ccp.c Ccp.h Ccp_Cfg.c Ccp_Cfg.h
  group Source/ComStack/Com
    ../Source/ComStack/Com/: Com.c Com.h Com_Cbk.h Com_Types.h
  group Source/ComStack/Common
    ../Source/ComStack/Common/: Compiler.h Compiler_Cfg.h ComStack_Types.h MemMap.h Platform_Types.h Std_Types.h
  group Source/ComStack/Dcm
    ../Source/ComStack/Dcm/: Dcm.c Dcm.h Dcm_Cbk.c Dcm_Cbk.h Dcm_Types.h
  group Source/ComStack/PDUR
    ../Source/ComStack/PDUR/: PduR.c PduR.h PduR_CanTp.h PduR_Cfg.h PduR_Dcm.h PduR_Types.h
  group Source/Drivers/CMSIS/Device/FM/FM33xx/Include
    ../Source/Drivers/CMSIS/Device/FM/FM33xx/Include/: core_cm0plus.h core_cmFunc.h core_cmInstr.h fm33_assert.h fm33lg0xx.h fm33xx.h system_fm33lg0xx.h
  group Source/Drivers/CMSIS/Device/FM/FM33xx/Source
    ../Source/Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
  group Source/Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/iar
    ../Source/Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/iar/: startup_fm33lg0xx.s
  group Source/Drivers/FM33LG0xx_FL_Driver/Inc
    ../Source/Drivers/FM33LG0xx_FL_Driver/Inc/: fm33_assert.h fm33lg0xx_fl.h fm33lg0xx_fl_adc.h fm33lg0xx_fl_aes.h fm33lg0xx_fl_atim.h fm33lg0xx_fl_bstim16.h fm33lg0xx_fl_bstim32.h fm33lg0xx_fl_can.h fm33lg0xx_fl_cdif.h fm33lg0xx_fl_cmu.h fm33lg0xx_fl_comp.h fm33lg0xx_fl_conf.h fm33lg0xx_fl_crc.h fm33lg0xx_fl_dac.h fm33lg0xx_fl_def.h fm33lg0xx_fl_divas.h fm33lg0xx_fl_dma.h fm33lg0xx_fl_exti.h fm33lg0xx_fl_flash.h fm33lg0xx_fl_gpio.h fm33lg0xx_fl_gptim.h fm33lg0xx_fl_i2c.h fm33lg0xx_fl_iwdt.h fm33lg0xx_fl_lcd.h fm33lg0xx_fl_lptim16.h fm33lg0xx_fl_lptim32.h fm33lg0xx_fl_lpuart.h fm33lg0xx_fl_pmu.h fm33lg0xx_fl_rmu.h fm33lg0xx_fl_rng.h fm33lg0xx_fl_rtca.h fm33lg0xx_fl_spi.h fm33lg0xx_fl_svd.h fm33lg0xx_fl_uart.h fm33lg0xx_fl_vao.h fm33lg0xx_fl_vref.h fm33lg0xx_fl_vrefp.h fm33lg0xx_fl_wwdt.h
  group Source/Drivers/FM33LG0xx_FL_Driver/Src
    ../Source/Drivers/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_can.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_exti.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_svd.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_vao.c fm33lg0xx_fl_vrefp.c fm33lg0xx_fl_wwdt.c
  group Source/drv/Adc
    ../Source/drv/Adc/: Adc_Drv.c Adc_Drv.h
  group Source/drv/DMA
    ../Source/drv/DMA/: DMA.c DMA.h
  group Source/drv/EE_Flash
    ../Source/drv/EE_Flash/: eeprom.c eeprom.h eeprom_cfg.c eeprom_cfg.h
  group Source/drv/Encoder
    ../Source/drv/Encoder/: EncoderDrv.c EncoderDrv.h
  group Source/drv/Event
    ../Source/drv/Event/: Event.c Event.h
  group Source/drv/GPIO
    ../Source/drv/GPIO/: Gpio.c Gpio.h
  group Source/drv/Keyboard
    ../Source/drv/Keyboard/: adc_keyboard_driver.c adc_keyboard_driver.h keyboard_config.c keyboard_config.h keyboard_driver.c keyboard_driver.h keyboard_io_driver.c keyboard_io_driver.h
  group Source/drv/Memory
    ../Source/drv/Memory/: Memory.c Memory.h
  group Source/drv/PLL
    ../Source/drv/PLL/: Pll.c Pll.h
  group Source/drv/PWM
    ../Source/drv/PWM/: Pwm.c Pwm.h
  group Source/drv/Sleep
    ../Source/drv/Sleep/: Sleep.c Sleep.h
  group Source/drv/svd
    ../Source/drv/svd/: svd.c svd.h svd_interrupt.c svd_interrupt.h
  group Source/drv/Tim
    ../Source/drv/Tim/: Tim.c Tim.h
  group Source/MF-config/Inc
    ../Source/MF-config/Inc/: mf_config.h
  group Source/MF-config/Src
    ../Source/MF-config/Src/: mf_config.c
  group Source/types
    ../Source/types/: error.h os_types.h types.h
